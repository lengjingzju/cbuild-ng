inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/examples/test-mod/test-hello"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/examples/test-mod/test-hello"
