inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/examples/test-mod/test-two-mods"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/examples/test-mod/test-two-mods"
