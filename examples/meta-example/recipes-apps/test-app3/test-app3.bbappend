inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/examples/test-app/test-app3"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/examples/test-app/test-app3"
