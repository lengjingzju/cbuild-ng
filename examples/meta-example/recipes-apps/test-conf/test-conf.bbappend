inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/examples/test-conf"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/examples/test-conf"
