inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/scripts/kconfig"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/scripts/kconfig"
