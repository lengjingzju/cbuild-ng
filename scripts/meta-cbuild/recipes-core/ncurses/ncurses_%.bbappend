EXCONFIG_ARGS:append = " --with-static --with-normal"
