LICENSE = "MIT"
LIC_FILES_CHKSUM = ""

SRC_URI = ""

include ${TOPDIR}/config/${PN}.inc
EXTRADEPS = 'unselect'

do_configure () {
	:
}

do_compile () {
	:
}

do_install () {
	:
}

ALLOW_EMPTY:${PN} = "1"
